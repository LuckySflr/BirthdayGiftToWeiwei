# Keil uVision project test_board.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F005 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0x7FF) IROM(0-0x7FFF) CLOCK(20000000)
  output: test_board +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c music.c led.c
